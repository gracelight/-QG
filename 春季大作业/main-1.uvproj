# Keil uVision project main-1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: main-1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main-1.c game.c LCD12864.c keypad.c sound.c config.c eeprom.c
